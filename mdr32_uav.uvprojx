# Keil uVision project mdr32_uav.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mdr32_uav +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: .\libs\simonk_esc;.\libs\clock_setup;.\libs\uart_setup;.\libs\ibus
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./user/: main.c
  group libs
    ./libs/simonk_esc/: esc_control.c
    ./libs/ibus/: ibus.c
    ./libs/uart_setup/: uart.c
    ./libs/clock_setup/: clock.c
software components: Device:Startup 2.1.0i, Drivers:EEPROM 2.1.0i, Drivers:PORT 2.0.3i, Drivers:RST_CLK 2.0.3i, Drivers:TIMER 2.1.0i, Drivers:UART 2.1.0i, Drivers:UTILS 1.0.0i
